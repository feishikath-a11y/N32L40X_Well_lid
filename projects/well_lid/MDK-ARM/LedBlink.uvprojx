# Keil uVision project LedBlink.uvprojx, settings and files
target n32l40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32l40x_std_periph_driver\inc;..\src\com\easylogger\inc;..\src\int;..\src\com\easylogger\plugins\file;..\src\com\easylogger\plugins\flash;..\src\dri;..\src\com
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32l40x.c
  group USER
    ../src/: main.c n32l40x_it.c
  group DOC
    ../: readme.txt
  group src\com\log
    ../src/com/easylogger/plugins/file/: elog_file.c elog_file_port.c
    ../src/com/easylogger/port/: elog_port.c
    ../src/com/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group src\int\int_LED
    ../src/int/: int_LED.c
  group dri
    ../src/dri/: dri_ClockConfig.c dri_usart.c dri_Systick.c
  group firmware
    ../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
